# Repository pklopping/Microscope-Light-Ring

File README.md:

# Microscope Light Ring

This light ring is designed for use on a Bausch + Lomb Stereo View 7 microscope. It's mounted with a modified version of the part found here: http://transistor-man.com/bausch_lomb_microscope_light.html

The 555 timer configuration was found here:

The mosfet configuration was found here: https://diyodemag.com/education/fundamentals_versatile_555_timer_pwm_control

As of right now, it's still in its prototyping phase and you probably shouldn't make one.

## Credits
Schematic and PCB design: Paul Klopping https://github.com/pklopping
EE santiy checking: Tony K https://github.com/elwoodblues

## KiCad design Microscope-Light-Ring/Microscope-Light-Ring.kicad_pcb

Parts:
C1, C2: 0.1µF; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C3: 47µF; C_1210_3225Metric_Pad1.42x2.65mm_HandSolder
D1, D3, D5, D7, D9, D11, D13, D15, D17, D19, D21, D23, D25, D27, D29, D31: D; D_1206_3216Metric_Pad1.42x1.75mm_HandSolder
D2, D4, D6, D8, D10, D12, D14, D16, D18, D20, D22, D24, D26, D28, D30, D32: LED; LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder
D33, D34: 1N4148; D_SOD-123
J1: Barrel_Jack_Switch; BarrelJack_Horizontal
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16: 133; R_1210_3225Metric_Pad1.42x2.65mm_HandSolder
R17: 1K; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R18: 10K; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R19: 120; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
RV1: 10K; RK09D1130C2P ALPS Potentiometer
SW1: A11203RNCQ; A11203RSCQ-12ps-1p-sw
U1: NE555; SO-8_5.3x6.2mm_P1.27mm
U2: IRF540N; TO-263-2

Connections:
+12V: C3.1, J1.1, R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, R9.2, R10.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, R17.1, U1.4 (R), U1.8 (VCC)
GND: C1.2, C2.2, C3.2, J1.2, R18.1, U1.1 (GND), U2.2
unnamed: C1.1, RV1.2, U1.2 (TR), U1.6 (THR)
unnamed: C2.1, U1.5 (CV)
unnamed: D1.1 (K), D25.1 (K), SW1.9
unnamed: D1.2 (A), D2.1 (K), D3.2 (A), D4.1 (K), D5.2 (A), D6.1 (K), D7.2 (A), D8.1 (K)
unnamed: D2.2 (A), R1.1
unnamed: D3.1 (K), D9.1 (K), SW1.8
unnamed: D4.2 (A), R2.1
unnamed: D5.1 (K), SW1.5
unnamed: D6.2 (A), R3.1
unnamed: D8.2 (A), R4.1
unnamed: D9.2 (A), D10.1 (K), D11.2 (A), D12.1 (K), D13.2 (A), D14.1 (K), D15.2 (A), D16.1 (K)
unnamed: D10.2 (A), R5.1
unnamed: D11.1 (K), D17.1 (K), SW1.7
unnamed: D12.2 (A), R6.1
unnamed: D13.1 (K), SW1.4
unnamed: D14.2 (A), R7.1
unnamed: D7.1 (K), D15.1 (K), D23.1 (K), D31.1 (K), SW1.1
unnamed: D16.2 (A), R8.1
unnamed: D17.2 (A), D18.1 (K), D19.2 (A), D20.1 (K), D21.2 (A), D22.1 (K), D23.2 (A), D24.1 (K)
unnamed: D18.2 (A), R9.1
unnamed: D19.1 (K), D27.1 (K), SW1.6
unnamed: D20.2 (A), R10.1
unnamed: D21.1 (K), SW1.3
unnamed: D22.2 (A), R11.1
unnamed: D24.2 (A), R12.1
unnamed: D25.2 (A), D26.1 (K), D27.2 (A), D28.1 (K), D29.2 (A), D30.1 (K), D31.2 (A), D32.1 (K)
unnamed: D26.2 (A), R13.1
unnamed: D28.2 (A), R14.1
unnamed: D29.1 (K), SW1.2
unnamed: D30.2 (A), R15.1
unnamed: D32.2 (A), R16.1
unnamed: D33.1 (K), RV1.3
unnamed: D33.2 (A), D34.1 (K), R17.2, U1.7 (DIS)
unnamed: D34.2 (A), RV1.1
unnamed: R18.2, R19.1, U2.1
unnamed: R19.2, U1.3 (Q)
unnamed: SW1.A, U2.3

Notes on the sheet:
Top
Right
Left
Bottom
All
Top Right
Bottom Right
Bottom Left
Top Left

Board: 2 copper layers, 119.1 x 78.1 mm, 61 parts (3 on the bottom side), 39 nets.

## Commit log

2019-08-17 First commit, rough, draft, very crude, pls don't judge me based on this
2019-08-17 Messier, but cleaner. Now I need a clever
2019-08-17 Messier, but cleaner. Now I need a clever take 2
2019-08-18 Why not
2019-08-18 Footprints assigned
2019-08-18 Started looking at the big resistors... prolly gonna switch to PWM instead
2019-08-18 Oops, put in the wrong datasheet for the resistors
2019-08-20 555 timer as a PWM controller? Seems legit. Let's try it
2019-08-21 Picked a pot, made a footprint
2019-08-21 Finished picking parts. Started untangling the ratsnest
2019-08-21 Oh boy. How am I gonna fit all these
2019-08-21 Putting the knobs on the back side
2019-08-21 Thanks spreadsheets! Laid out all the leds and their resistors
2019-08-22 Oh boy, I'm not looking forward to routing this
2019-08-22 Mostly laid out. Time to obsess over every single track
2019-08-22 Worked on the layout some more. Will probably keep tweaking it for a week
2019-08-22 Forgot to add this. Oops
2019-08-24 Made a couple small tweaks to the traces. I might add a capacitor to the 12v rail
2019-08-24 Adding a probably unnecessary bulk cap
2019-08-24 Adding an annotation and other minor silkscreen tweaks
2019-08-24 Alright. Ship it. I'm sure it'll be fine.
2019-08-24 Oops. Had the wrong footprint for the 555 timer
2019-08-25 Different mosfet with a pulldown resistor. Turns out I was probably wrong on on the last design
2019-08-25 Adding a first version of the readme
2019-08-25 Updating the readme with more links
2019-08-25 Adding a current limiting resistor to the mosfet. Hopefully it won't affect the switching frequency too much
2019-08-25 Some final tweaks before sending it for real
